# Keil uVision project LVGL_Test.uvprojx, settings and files
target LVGL_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: LVGL_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP/LCD;../Middleware/LVGL;../Middleware/LVGL/lvgl;../Middleware/LVGL/lvgl_app;../Middleware/LVGL/lvgl/src/core;../Middleware/LVGL/lvgl/src/display;../Middleware/LVGL/lvgl/src/draw;../Middleware/LVGL/lvgl/src/drivers;../Middleware/LVGL/lvgl/src/font;../Middleware/LVGL/lvgl/src/indev;../Middleware/LVGL/lvgl/src/layouts;../Middleware/LVGL/lvgl/src/libs;../Middleware/LVGL/lvgl/src/misc;../Middleware/LVGL/lvgl/src/osal;../Middleware/LVGL/lvgl/src/others;../Middleware/LVGL/lvgl/src/stdlib;../Middleware/LVGL/lvgl/src/themes;../Middleware/LVGL/lvgl/src/tick;../Middleware/LVGL/lvgl/src/widgets;../Middleware/LVGL/lvgl/demos;../Middleware/LVGL/lvgl/demos/widgets;../BSP/LCD_TOUCH
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\EIDE\mine.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fmc.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../BSP/LCD/: lcd.c
    ../BSP/LCD_TOUCH/: lcd_touch.c
  group LVGL/src
    ../Middleware/LVGL/lvgl/src/: lv_init.c
    ../Middleware/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Middleware/LVGL/lvgl/src/display/: lv_display.c
    ../Middleware/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middleware/LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middleware/LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../Middleware/LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middleware/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middleware/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../Middleware/LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Middleware/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middleware/LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middleware/LVGL/lvgl/src/layouts/: lv_layout.c
    ../Middleware/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../Middleware/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../Middleware/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middleware/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middleware/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../Middleware/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middleware/LVGL/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_utils.c lv_xml_widget.c
    ../Middleware/LVGL/lvgl/src/others/xml/parsers/: lv_xml_button_parser.c lv_xml_chart_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_slider_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c
    ../Middleware/LVGL/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Middleware/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Middleware/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middleware/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../Middleware/LVGL/lvgl/src/others/monkey/: lv_monkey.c
    ../Middleware/LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middleware/LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middleware/LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middleware/LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middleware/LVGL/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager_utils.c
    ../Middleware/LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middleware/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../Middleware/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middleware/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middleware/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middleware/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middleware/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middleware/LVGL/lvgl/src/themes/: lv_theme.c
    ../Middleware/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middleware/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middleware/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../Middleware/LVGL/lvgl/src/tick/: lv_tick.c
    ../Middleware/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middleware/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../Middleware/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../Middleware/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../Middleware/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middleware/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middleware/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middleware/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../Middleware/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middleware/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middleware/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../Middleware/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middleware/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middleware/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../Middleware/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../Middleware/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../Middleware/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../Middleware/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middleware/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../Middleware/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middleware/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middleware/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middleware/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../Middleware/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../Middleware/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../Middleware/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../Middleware/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middleware/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middleware/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../Middleware/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../Middleware/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middleware/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middleware/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middleware/LVGL/lvgl/src/widgets/win/: lv_win.c
  group LVGL/port
    ../Middleware/LVGL/lvgl/: lv_port_disp.c lv_port_indev.c lv_conf.h
  group LVGL/app
    ../Middleware/LVGL/lvgl_app/: user_lv.c
software components: CMSIS:CORE 4.3.0
